# Keil uVision project GongChuang_CarBoard.uvprojx, settings and files
target GongChuang_CarBoard (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GongChuang_CarBoard +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../APP;../BSP;../Module;../Math
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group APP
    ../APP/: App.c App.h App_questions.c App_questions.h App_task.c App_task.h
  group Module
    ../Module/: Mod_BlueTooth.c Mod_BlueTooth.h Mod_IMUMSPM0.c Mod_IMUMSPM0.h Mod_Key.c Mod_Key.h Mod_LED.c Mod_LED.h Mod_StepMotor.c Mod_StepMotor.h Mod_MAIXCAM.c Mod_MAIXCAM.h Mod_OLED.c Mod_OLED.h Mod_OLED_Data.c Mod_OLED_Data.h Mod_Buzzer.c Mod_Buzzer.h Mod_StepMotorArm.h Mod_StepMotorArm.c Mod_Servo.h Mod_Servo.c Mod_LCD.h Mod_LCD.c Mod_LCD_Data.h
  group BSP
    ../BSP/: BSP_BlueTooth.c BSP_BlueTooth.h BSP_DWT.c BSP_DWT.h BSP_IMUMSPM0.c BSP_IMUMSPM0.h BSP_Key.c BSP_Key.h BSP_LED.c BSP_LED.h BSP_UART.c BSP_UART.h BSP_X_V2.c BSP_X_V2.h BSP_MAIXCAM.h BSP_MAIXCAM.c BSP_OLED.c BSP_OLED.h BSP_Buzzer.c BSP_Buzzer.h BSP_Servo.c BSP_Servo.h BSP_LCD.c BSP_LCD.h
  group Math
    ../Math/: PID.c PID.h
software components: CMSIS:CORE 4.3.0
